# Keil uVision project temperatureLogger.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51AC3 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x7FF) CLOCK(40000000) MODP2
  output: temperatureLogger +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 TempLogger.c phys340libkeil.obj phys340libkeil.h t89c51ac3.h
